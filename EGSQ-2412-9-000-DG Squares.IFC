Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-2412-9-000-DG Squares.IFC
Time: 2024-11-05T12:49:27+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 25.6490320000001155; Volume Measure: 0.0256490320000001; Area Measure: 6.9573986530214436

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 25.6490320000001155; Volume Measure: 0.0256490320000001; Area Measure: 6.9573986530214436

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 25.6490320000001155; Volume Measure: 0.0256490320000001; Area Measure: 6.9573986530214436

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-2412-9-000-DG Squares | PSet_Mass_Property - Mass Measure: 25.6490320000001155; Volume Measure: 0.0256490320000001; Area Measure: 6.9573986530214436
EGSQ-2412-9-000-DG Squares | SOLIDWORKS Custom Properties - Description: SQUARES; PartNo: EGSQ-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

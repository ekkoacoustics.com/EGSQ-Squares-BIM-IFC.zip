Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-66-12-000-DG Squares.IFC
Time: 2024-11-05T12:49:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.6312719999999956; Volume Measure: 0.0086312720000000; Area Measure: 1.8001317450807228

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.6312719999999956; Volume Measure: 0.0086312720000000; Area Measure: 1.8001317450807228

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.6312719999999956; Volume Measure: 0.0086312720000000; Area Measure: 1.8001317450807228

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-66-12-000-DG Squares | PSet_Mass_Property - Mass Measure: 8.6312719999999956; Volume Measure: 0.0086312720000000; Area Measure: 1.8001317450807228
EGSQ-66-12-000-DG Squares | SOLIDWORKS Custom Properties - Description: SQUARE; PartNo: EGSQ-66-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-66-12-000-SG Squares.IFC
Time: 2024-11-05T12:49:46+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 9.2224080000000033; Volume Measure: 0.0092224080000000; Area Measure: 1.8784072777549752

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 9.2224080000000033; Volume Measure: 0.0092224080000000; Area Measure: 1.8784072777549752

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 9.2224080000000033; Volume Measure: 0.0092224080000000; Area Measure: 1.8784072777549752

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-66-12-000-SG Squares | PSet_Mass_Property - Mass Measure: 9.2224080000000033; Volume Measure: 0.0092224080000000; Area Measure: 1.8784072777549752
EGSQ-66-12-000-SG Squares | SOLIDWORKS Custom Properties - PartNo: EGSQ-66-12-000-SG; Description: SQUARE; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

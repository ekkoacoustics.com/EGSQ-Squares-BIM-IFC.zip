Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-66-9-000-SG Squares.IFC
Time: 2024-11-05T12:50:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 3.1764959999999984; Volume Measure: 0.0031764960000000; Area Measure: 0.8237572051176824

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 3.1764959999999984; Volume Measure: 0.0031764960000000; Area Measure: 0.8237572051176824

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 3.1764959999999984; Volume Measure: 0.0031764960000000; Area Measure: 0.8237572051176824

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-66-9-000-SG Squares | PSet_Mass_Property - Mass Measure: 3.1764959999999984; Volume Measure: 0.0031764960000000; Area Measure: 0.8237572051176824
EGSQ-66-9-000-SG Squares | SOLIDWORKS Custom Properties - Description: SQUARE; PartNo: EGSQ-66-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

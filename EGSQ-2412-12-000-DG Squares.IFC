Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-2412-12-000-DG Squares.IFC
Time: 2024-11-05T12:48:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 31.8693119999998977; Volume Measure: 0.0318693120000000; Area Measure: 6.6466402895288592

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 31.8693119999998977; Volume Measure: 0.0318693120000000; Area Measure: 6.6466402895288592

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 31.8693119999998977; Volume Measure: 0.0318693120000000; Area Measure: 6.6466402895288592

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-2412-12-000-DG Squares | PSet_Mass_Property - Mass Measure: 31.8693119999998977; Volume Measure: 0.0318693120000000; Area Measure: 6.6466402895288592
EGSQ-2412-12-000-DG Squares | SOLIDWORKS Custom Properties - Description: SQUARES; PartNo: EGSQ-2412-12-00-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

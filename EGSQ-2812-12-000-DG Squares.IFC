Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-2812-12-000-DG Squares.IFC
Time: 2024-11-05T12:46:21+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 37.1808640000000139; Volume Measure: 0.0371808640000000; Area Measure: 7.7544136711170051

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 37.1808640000000139; Volume Measure: 0.0371808640000000; Area Measure: 7.7544136711170051

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 37.1808640000000139; Volume Measure: 0.0371808640000000; Area Measure: 7.7544136711170051

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-2812-12-000-DG Squares | PSet_Mass_Property - Mass Measure: 37.1808640000000139; Volume Measure: 0.0371808640000000; Area Measure: 7.7544136711170051
EGSQ-2812-12-000-DG Squares | SOLIDWORKS Custom Properties - Description: SQUARES; PartNo: EGSQ-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

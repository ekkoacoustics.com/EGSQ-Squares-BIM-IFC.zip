Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-2412-9-000-SG Squares.IFC
Time: 2024-11-05T12:49:10+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 25.4119679999999093; Volume Measure: 0.0254119679999999; Area Measure: 6.5900576409414660

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 25.4119679999999093; Volume Measure: 0.0254119679999999; Area Measure: 6.5900576409414660

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 25.4119679999999093; Volume Measure: 0.0254119679999999; Area Measure: 6.5900576409414660

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-2412-9-000-SG Squares | PSet_Mass_Property - Mass Measure: 25.4119679999999093; Volume Measure: 0.0254119679999999; Area Measure: 6.5900576409414660
EGSQ-2412-9-000-SG Squares | SOLIDWORKS Custom Properties - Description: SQUARES; PartNo: EGSQ-2412-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2

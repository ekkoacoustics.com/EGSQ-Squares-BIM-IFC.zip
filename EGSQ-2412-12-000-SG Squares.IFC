Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Squares\EGSQ-2412-12-000-SG Squares.IFC
Time: 2024-11-05T12:48:37+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 34.0519679999999809; Volume Measure: 0.0340519680000002; Area Measure: 6.9356576409414403

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 34.0519679999999809; Volume Measure: 0.0340519680000002; Area Measure: 6.9356576409414403

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 34.0519679999999809; Volume Measure: 0.0340519680000002; Area Measure: 6.9356576409414403

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGSQ-2412-12-000-SG Squares | PSet_Mass_Property - Mass Measure: 34.0519679999999809; Volume Measure: 0.0340519680000002; Area Measure: 6.9356576409414403
EGSQ-2412-12-000-SG Squares | SOLIDWORKS Custom Properties - Description: SQUARES; PartNo: ESGQ-2412-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedDate: 24.10.2024; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; DrawnBy: CAM; sets with these values: 2
